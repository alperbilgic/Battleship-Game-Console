# Keil uVision project Proje.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Proje
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: initSSI.s initGPIO.s Startup.s Delayy.s sendDC.s fillzero.s maincursor.s deneme.s get_column.s buttonhandler.s gpio_f.s civilian.s and_or.s screenzero.s battleshipmult.s battlescreen.s newscreenzero.s mine.s get_row_col_mine.s screen2.s screen3.s buttons2.s systickhandler.s systick.s timetable.s decision.s p1_won.s p2_won.s
